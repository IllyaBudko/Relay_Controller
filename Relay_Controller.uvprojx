# Keil uVision project Relay_Controller.uvprojx, settings and files
target Source (ARM-ADS)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Relay_Controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F030F4Px/STCubeGenerated/Src/: main.c stm32f0xx_it.c
    ./RTE/Device/STM32F030F4Px/STCubeGenerated/Inc/: stm32f0xx_it.h
software components: CMSIS:CORE 5.3.0, Device:STM32Cube HAL 1.11.0
